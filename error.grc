<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplificar</value></param>
<param><key>value</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>amplificar</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amplificar</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audioRate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>audioRate</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>127</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amplificar</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>127</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Audio sin cuantizar"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>4*audioRate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1, 1, 1, 1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Audio cuantizado</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>4*audioRate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Error de cuantizacion</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>4*audioRate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0.3</value></param>
<param><key>ymin</key><value>-0.3</value></param>
</block>
<block>
<key>vocoder_ulaw_decode_bs</key>
<param><key>id</key><value>vocoder_ulaw_decode_bs_0</value></param>
</block>
<block>
<key>vocoder_ulaw_encode_sb</key>
<param><key>id</key><value>vocoder_ulaw_encode_sb_0</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>vocoder_ulaw_encode_sb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_ulaw_decode_bs_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_ulaw_encode_sb_0</source_block_id><sink_block_id>vocoder_ulaw_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
